DESCRIPTION = "Generic Victron image"

require venus-image.inc

IMAGE_ROOTFS_SIZE_raspberrypi2 = "512000"
